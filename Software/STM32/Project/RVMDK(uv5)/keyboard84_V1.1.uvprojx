# Keil uVision project keyboard84_V1.1.uvprojx, settings and files
target keybaord (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32L053R8Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: keyboard84_V1.1 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32L053xx,USE_HAL_DRIVER,USE_FULL_LL_DRIVER
  c misc: --C99
  c include: ..\..\Libraries\CMSIS;..\..\Libraries\FWlib\inc;..\..\Libraries\USB\Class\HID\Inc;..\..\Libraries\USB\Core\Inc;..\..\User\BSP\inc;..\..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32l053xx.s
  group CMSIS
    ../../Libraries/CMSIS/: system_stm32l0xx.c
  group FWlib
    ../../Libraries/FWlib/src/: stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_crc.c stm32l0xx_hal_crc_ex.c stm32l0xx_hal_cryp.c stm32l0xx_hal_cryp_ex.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_iwdg.c stm32l0xx_hal_pcd.c stm32l0xx_hal_pcd_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rng.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_tsc.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_usart.c stm32l0xx_hal_wwdg.c stm32l0xx_ll_spi.c stm32l0xx_ll_adc.c stm32l0xx_ll_comp.c stm32l0xx_ll_crc.c stm32l0xx_ll_crs.c stm32l0xx_ll_dac.c stm32l0xx_ll_dma.c stm32l0xx_ll_exti.c stm32l0xx_ll_gpio.c stm32l0xx_ll_i2c.c stm32l0xx_ll_lptim.c stm32l0xx_ll_lpuart.c stm32l0xx_ll_pwr.c stm32l0xx_ll_rcc.c stm32l0xx_ll_rng.c stm32l0xx_ll_rtc.c stm32l0xx_ll_tim.c stm32l0xx_ll_usart.c stm32l0xx_ll_utils.c
  group USB
    ../../Libraries/USB/Class/HID/Src/: usbd_hid.c
    ../../Libraries/USB/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../../User/: usbd_conf.c usbd_desc.c
  group BSP
    ../../User/BSP/src/: bsp_gpio.c bsp_timer.c bsp_usb.c bsp_74hc595.c bsp_uart_fifo.c bsp_pwm.c bsp_lowpwr.c
  group USER
    ../../User/BSP/src/: bsp.c
    ../../User/: main.c stm32l0xx_it.c user_display.c keymap.c keyboard.c user_key.c
software components: CMSIS:CORE 4.3.0
