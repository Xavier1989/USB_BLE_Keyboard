# Keil uVision project keyboard_ref_des.uvprojx, settings and files
target keyboard_ref_des (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: keyboard_ref_des +hex
  c flags: Optim=4 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --c99 --thumb -c --preinclude da14580_config.h --feedback=".\system\unused.txt"
  c include: ..\..\..\src\modules\app\src\app_project\keyboard;..\..\..\src\modules\app\src\app_project\spotar_fh;..\..\..\src\modules\app\src\app_profiles\spotar;.\..\..\..\src\dialog\include;c:\Keil\ARM\CMSIS\Include;C:\Keil\ARM\RV31\INC;.\..\..\..\src\plf\refip\src\arch;.\..\..\..\src\plf\refip\src\arch\compiler\rvds;.\..\..\..\src\plf\refip\src\arch\boot\rvds;.\..\..\..\src\plf\refip\src\arch\ll\rvds;.\..\..\..\src\plf\refip\src\driver\reg;.\..\..\..\src\modules\common\api;.\..\..\..\src\modules\dbg\api;.\..\..\..\src\modules\display\api;.\..\..\..\src\modules\gtl\api;.\..\..\..\src\modules\ke\api;.\..\..\..\src\modules\ke\src;.\..\..\..\src\modules\nvds\api;.\..\..\..\src\modules\rf\api;.\..\..\..\src\modules\rwip\api;.\..\..\..\src\ip\ble\ll\src\rwble;.\..\..\..\src\ip\ble\ll\src\controller\em;.\..\..\..\src\ip\ble\ll\src\controller\llc;.\..\..\..\src\ip\ble\ll\src\controller\lld;.\..\..\..\src\ip\ble\ll\src\controller\llm;.\..\..\..\src\plf\refip\src\driver\led;.\..\..\..\src\plf\refip\src\driver\timer;.\..\..\..\src\plf\refip\src\driver\syscntl;.\..\..\..\src\plf\refip\src\driver\emi;.\..\..\..\src\plf\refip\src\driver\uart;.\..\..\..\src\plf\refip\src\driver\flash;.\..\..\..\src\plf\refip\src\driver\gpio;.\..\..\..\src\ip\ble\hl\src\host\att;.\..\..\..\src\ip\ble\hl\src\host\att\attc;.\..\..\..\src\ip\ble\hl\src\host\att\attm;.\..\..\..\src\ip\ble\hl\src\host\gap;.\..\..\..\src\ip\ble\hl\src\host\gap\gapc;.\..\..\..\src\ip\ble\hl\src\host\gap\gapm;.\..\..\..\src\ip\ble\hl\src\host\att\atts;.\..\..\..\src\ip\ble\hl\src\host\gatt;.\..\..\..\src\ip\ble\hl\src\host\gatt\gattc;.\..\..\..\src\ip\ble\hl\src\host\gatt\gattm;.\..\..\..\src\ip\ble\hl\src\host\l2c\l2cc;.\..\..\..\src\ip\ble\hl\src\host\l2c\l2cm;.\..\..\..\src\ip\ble\hl\src\host\smp\smpc;.\..\..\..\src\ip\ble\hl\src\host\smp\smpm;.\..\..\..\src\ip\ble\hl\src\profiles;.\..\..\..\src\ip\ble\hl\src\profiles\accel;.\..\..\..\src\ip\ble\hl\src\profiles\bas\basc;.\..\..\..\src\ip\ble\hl\src\profiles\bas\bass;.\..\..\..\src\ip\ble\hl\src\profiles\blp;.\..\..\..\src\ip\ble\hl\src\profiles\blp\blpc;.\..\..\..\src\ip\ble\hl\src\profiles\blp\blps;.\..\..\..\src\ip\ble\hl\src\profiles\dis\disc;.\..\..\..\src\ip\ble\hl\src\profiles\dis\diss;.\..\..\..\src\ip\ble\hl\src\profiles\find\findl;.\..\..\..\src\ip\ble\hl\src\profiles\find\findt;.\..\..\..\src\ip\ble\hl\src\profiles\hogp;.\..\..\..\src\ip\ble\hl\src\profiles\hogp\hogpbh;.\..\..\..\src\ip\ble\hl\src\profiles\hogp\hogpd;.\..\..\..\src\ip\ble\hl\src\profiles\hogp\hogprh;.\..\..\..\src\ip\ble\hl\src\profiles\hrp;.\..\..\..\src\ip\ble\hl\src\profiles\hrp\hrpc;.\..\..\..\src\ip\ble\hl\src\profiles\hrp\hrps;.\..\..\..\src\ip\ble\hl\src\profiles\htp;.\..\..\..\src\ip\ble\hl\src\profiles\htp\htpc;.\..\..\..\src\ip\ble\hl\src\profiles\htp\htpt;.\..\..\..\src\ip\ble\hl\src\profiles\prox\proxm;.\..\..\..\src\ip\ble\hl\src\profiles\prox\proxr;.\..\..\..\src\ip\ble\hl\src\profiles\scpp;.\..\..\..\src\ip\ble\hl\src\profiles\scpp\scppc;.\..\..\..\src\ip\ble\hl\src\profiles\scpp\scpps;.\..\..\..\src\plf\refip\src\driver\intc;.\..\..\..\src\ip\ble\hl\src\rwble_hl;.\..\..\..\src\ip\ble\ll\src\hcic;.\..\..\..\src\ip\ble\hl\src\host\smp;.\..\..\..\src\modules\app\api;.\..\..\..\src\modules\app\src;.\..\..\..\src\modules\app\src\keyboard;.\..\..\..\src\modules\gtl\src;.\..\..\..\src\ip\ble\hl\src\profiles\anp;.\..\..\..\src\ip\ble\hl\src\profiles\anp\anpc;.\..\..\..\src\ip\ble\hl\src\profiles\anp\anps;.\..\..\..\src\ip\ble\hl\src\profiles\cscp;.\..\..\..\src\ip\ble\hl\src\profiles\cscp\cscpc;.\..\..\..\src\ip\ble\hl\src\profiles\cscp\cscps;.\..\..\..\src\ip\ble\hl\src\profiles\glp;.\..\..\..\src\ip\ble\hl\src\profiles\glp\glpc;.\..\..\..\src\ip\ble\hl\src\profiles\glp\glps;.\..\..\..\src\ip\ble\hl\src\profiles\pasp;.\..\..\..\src\ip\ble\hl\src\profiles\pasp\paspc;.\..\..\..\src\ip\ble\hl\src\profiles\pasp\pasps;.\..\..\..\src\ip\ble\hl\src\profiles\rscp;.\..\..\..\src\ip\ble\hl\src\profiles\rscp\rscpc;.\..\..\..\src\ip\ble\hl\src\profiles\rscp\rscps;.\..\..\..\src\ip\ble\hl\src\profiles\tip;.\..\..\..\src\ip\ble\hl\src\profiles\tip\tipc;.\..\..\..\src\ip\ble\hl\src\profiles\tip\tips;.\..\..\..\src\ip\ble\hl\src\profiles\spota\spotar;.\..\..\..\src\plf\refip\src\driver\i2c_eeprom;.\..\..\..\src\modules\app\src\app_profiles\bass;.\..\..\..\src\modules\app\src\app_profiles\diss;.\..\..\..\src\modules\app\src\modules\app\src\app_utils\app_alt_pair;.\..\..\..\src\modules\app\src\app_project\keyboard;.\..\..\..\src\modules\app\src\app_project\keyboard\common;.\..\..\..\src\modules\app\src\app_utils\app_alt_pair;.\..\..\..\src\plf\refip\src\driver\adc;.\..\..\..\src\plf\refip\src\driver\battery;.\..\..\..\src\plf\refip\src\driver\spi;.\..\..\..\src\plf\refip\src\driver\spi_flash;.\..\..\..\src\plf\refip\src\driver\wkupct_quadec;.\..\..\..\src\modules\app\src\app_utils\app_console;.\..\..\..\src\modules\app\src\app_utils\app_multi_bond;..\keyboard_ref_des;..\..\..\src\modules\app\src\app_project\keyboard\system;.\user
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\system\scatterfile_kbd.sct
  link misc: --via "system\linker_kbd.scr"
  group boot
    ./../../../src/plf/refip/src/arch/boot/rvds/: system_ARMCM0.c boot_vectors.s
  group arch
    ./../../../src/plf/refip/src/arch/main/ble/: arch_main.c jump_table.c
    ../../../src/plf/refip/src/arch/main/ble/: hardfault_handler.c arch_sleep.c nmi_handler.c arch_system.c
    ../../../src/modules/app/src/app_project/keyboard/system/: periph_setup.c
  group driver
    ./../../../src/modules/rf/src/: rf_580.c
    ../../../src/plf/refip/src/driver/gpio/: gpio.c
    ../../../src/plf/refip/src/driver/adc/: adc.c
    ../../../src/plf/refip/src/driver/battery/: battery.c
    ../../../src/plf/refip/src/driver/i2c_eeprom/: i2c_eeprom.c
    ../../../src/plf/refip/src/driver/wkupct_quadec/: wkupct_quadec.c
    ../../../src/plf/refip/src/driver/uart/: uart2.c
  group ke
    ../../../patch_code/obj/: ke_task.obj ch_map.obj ke_mem.obj
  group host
    ./../../../src/ip/ble/hl/src/host/gap/gapm/: gapm.c
    ../../../patch_code/obj/: atts_task.obj smpc.obj gapm_util.obj
  group nvds
    ./../../../src/modules/nvds/src/: nvds.c
  group rwble
    ./../../../src/modules/rwip/src/: rwip.c
    ./../../../src/ip/ble/ll/src/rwble/: rwble.c
  group profiles
    ./../../../src/ip/ble/hl/src/profiles/bas/bass/: bass.c bass_task.c
    ./../../../src/ip/ble/hl/src/profiles/dis/diss/: diss.c diss_task.c
    ./../../../src/ip/ble/hl/src/profiles/hogp/hogpd/: hogpd.c hogpd_task.c
    ./../../../src/ip/ble/hl/src/profiles/: prf_utils.c
    ../../../src/ip/ble/hl/src/profiles/spota/spotar/: spotar.c spotar_task.c
  group app
    ./../../../src/modules/app/src/: app.c app_task.c app_sec.c app_sec_task.c
    ../../../src/modules/app/src/app_profiles/bass/: app_batt.c app_batt_task.c
    ../../../src/modules/app/src/app_profiles/diss/: app_dis.c app_dis_task.c
    ../../../src/modules/app/src/app_project/keyboard/: app_kbd.c app_kbd_fsm.c app_kbd_leds.c app_kbd_proj.c app_kbd_proj_task.c app_kbd_scan_fsm.c app_white_list.c
    ../../../src/modules/app/src/app_utils/app_multi_bond/: app_multi_bond.c
    ../../../src/modules/app/src/app_utils/app_console/: app_console.c
    ../../../src/modules/app/src/app_profiles/spotar/: app_spotar.c app_spotar_task.c
  group user
    ./user/: user_uart2.c
